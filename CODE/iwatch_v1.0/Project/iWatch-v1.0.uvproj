# Keil uVision project iWatch-v1.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: iWatch-v1.1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\System;..\User\Sensor;..\User\Rtc;..\User\Radio;..\User\Oled;..\User\Bluetooth;..\User
  group Doc
    ../Doc/: README.txt
  group Oled
    ../User/System/: oled.c
  group System
    ../User/System/: PowerManage.c IIC.c Sys.c EEPROM.c Buzzer.c Delay.c Display.c
  group User
    ../User/: main.c
